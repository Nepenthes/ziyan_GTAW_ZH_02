# Keil uVision project GTAWZ-ZH-02.uvprojx, settings and files
target 物联网多功能组合实训系统GTAWZ-ZH-02 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GTAWZ-ZH-02 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;.\User;.\User\reWrite;..\Module\FlashOP;..\Module;..\Module\KEY&TIPS;..\Module\Transmitter_USART;..\Module\BEEP;..\Module\LCD(1.44inches);..\Module\LED_ARRAY;..\Module\LED_Spray;..\Module\LED_Grow;..\Module\SHT11;..\Module\TSL2561;..\Module\BMP180;..\Module\keyBoard;..\Module\SensorSIM;..\Module\Sensor_RT;..\Module\Sensor_Rain;..\Module\Sensor_contentCO2;..\Module\Sensor_windSpeed;..\Module\Sensor_soilHum;..\Module\RFID;..\Module\EXHUASH;..\Module\Curtain;..\Module\airWarming;..\Module\Phonetics;..\Module\sourceToggle;..\Module\RELAY;..\Module\ElectricMeter;..\Module\LCD4.3Touch\EMWIN;..\Module\LCD4.3Touch\EMWIN\Config;..\Module\LCD4.3Touch\EMWIN\inc;..\Module\LCD4.3Touch\EMWIN\Lib;..\Module\LCD4.3Touch\EMWIN\OS;..\Module\LCD4.3Touch\EMWINDEMO;..\Module\LCD4.3Touch\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group 用户文件
    ./User/: UsrMain.c stm32f10x_it.c Bsp.c SysSupport.c delay.c
    ../Module/: Test.c
    ../Module/FlashOP/: stmflash.c
    ./: SVC_Table.s
  group 指令机构
    ../Module/KEY&TIPS/: Key&Tips.c
    ../Module/BEEP/: beep.c
  group 通讯构件
    ../Module/Transmitter_USART/: WirelessTrans_USART.c
  group 显示构件
    ../Module/LCD(1.44inches)/: GUI_1.44.c LCD_1.44.c
    ../Module/LED_ARRAY/: LED_array.c
  group 传感器构件
    ../Module/SHT11/: SHT11.c
    ../Module/TSL2561/: TSL2561.c
    ../Module/BMP180/: BMP180.C bmp180_iic.c
    ../Module/SensorSIM/: Sensorsim.c
    ../Module/keyBoard/: keyBoard.c
    ../Module/Sensor_RT/: Sensor_RT.c
    ../Module/Sensor_Rain/: Sensor_Rain.c
    ../Module/RFID/: rc522_function.c rc522_config.c
    ../Module/Sensor_windSpeed/: windSpeed.c
    ../Module/Sensor_contentCO2/: contentCO2.c
    ../Module/Sensor_soilHum/: soilHum.c
    ../Module/Phonetics/: LD3320.c LD3320Chip.c LD3320Reg_RW.c
    ../Module/ElectricMeter/: ElecMeter.c
  group 执行器构件
    ../Module/LED_Spray/: ledSpray.c
    ../Module/LED_Grow/: ledGrow.c
    ../Module/EXHUASH/: exAir.c
    ../Module/airWarming/: airWarming.c
    ../Module/sourceToggle/: SourceTog.c
    ../Module/RELAY/: Relay.c
    ../Module/Curtain/: Curtain.c
  group 系统外设驱动改写
    ./User/reWrite/: USART_STM32F10x.c
  group 4.3寸LCD专用
    ../Module/LCD4.3Touch/HARDWARE/: LCD4.3Main.c lcd5510.c touch.c
    ../Module/LCD4.3Touch/EMWIN/Config/: GUIConf.c LCDConf.c GUIDRV_Template.c
    ../Module/LCD4.3Touch/EMWIN/OS/: GUI_X_Ex.c GUI_X_Touch_Analog.c
    ../Module/LCD4.3Touch/EMWIN/Lib/: GUI_CM3.lib
  group 工程记录
    ../../: GTAWZ-ZH-02_总结.txt
  group EMWINDEMO
    ../Module/LCD4.3Touch/EMWINDEMO/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_Touch.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, CMSIS Driver:CAN 1.6, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
